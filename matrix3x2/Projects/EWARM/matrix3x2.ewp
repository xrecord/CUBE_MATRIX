# IAR project matrix3x2.ewp, settings and files
configuration matrix3x2 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: matrix3x2 Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s startup_stm32f303xc.s
  group Application/User
    ../../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
